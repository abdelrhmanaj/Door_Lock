# IAR project HMI_ECU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C123GH6PM
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295\inc; C:\ti\TivaWare_C_Series-2.2.0.295\driverlib; C:\ti\TivaWare_C_Series-2.2.0.295
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: HMI_ECU.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/: main.c
  group CORE
    CORE/: password.c password.h tm4c123gh6pm.h
  group HAL
    HAL/: adc.c adc.h i2c_lcd.c i2c_lcd.h keypad.c keypad.h leds.c leds.h
  group MCAL
    MCAL/: systick.c systick.h uart1.c uart1.h

# IAR project Control_ECU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C123GH6PM
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295\inc; C:\ti\TivaWare_C_Series-2.2.0.295\driverlib; C:\ti\TivaWare_C_Series-2.2.0.295; D:\Fall2025\Intro ES\project\Door_Lock\Control_ECU\APP; D:\Fall2025\Intro ES\project\Door_Lock\Control_ECU\CORE; D:\Fall2025\Intro ES\project\Door_Lock\Control_ECU\HAL; D:\Fall2025\Intro ES\project\Door_Lock\Control_ECU\MACL
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Control_ECU.out
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/: main.c
  group CORE
    CORE/: massErase.h tm4c123gh6pm.h
  group HAL
    HAL/: buzzer.c buzzer.h motor.c motor.h
  group MCAL
    MCAL/: eeprom.c eeprom.h systick.c systick.h uart1.c uart1.h

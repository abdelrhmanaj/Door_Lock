# IAR project Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295\inc; C:\ti\TivaWare_C_Series-2.2.0.295\driverlib; C:\ti\TivaWare_C_Series-2.2.0.295
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Test.srec
  ILINK.IlinkOutputFile: Test.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c systick.c systick.h
    ../HMI_ECU/: tm4c123gh6pm.h
  group Control_ECU
    Control_ECU/: buzzer.c buzzer.h buzzerTest.h eeprom.c eeprom.h eepromTest.h motor.c motor.h motorTest.h UART&motor&buzzerTest.h uart1.c uart1.h UartTest.h
  group HMI_ECU
    HMI_ECU/: adc.c adc.h i2c_lcd.c i2c_lcd.h Keypad&Lcd&Poten..Test.h Keypad&LcdTest.h keypad.c keypad.h KeypadTest.h LcdTest.h leds.c leds.h password.c password.h PotentiometerTest.h
